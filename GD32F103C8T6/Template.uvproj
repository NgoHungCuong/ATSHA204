# Keil uVision project Template.uvproj, settings and files
target Template (ARM-ADS)
  device: GD32F103C8 GigaDevice
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x08000000-0x0800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  c flags: Optim=1
  c define: GD32F10X_MD, USE_STDPERIPH_DRIVER, HSE_VALUE=12000000
  c include: ..\I2C_LCD;..\Firmware\CMSIS;..\Firmware\Peripherals\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Firmware/: startup_gd32f10x_md.s
    ../Firmware/CMSIS/: system_gd32f10x.c
  group STD_Lib
    ../Firmware/Peripherals/src/: gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_rcc.c
  group User
    ./: gd32f10x_conf.h gd32f10x_it.c gd32f10x_it.h main.c systick.c systick.h
  group I2C_LCD
    ./: Soft_I2C.c Soft_I2C.h I2C_HW_CFG.h
  group SHA204
    ./: SHA204.c SHA204.h
